FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/6.18/:"

SRC_URI += " \
	file://0001-Add-compulab-iotg-rpi5-device-support.patch \
"
